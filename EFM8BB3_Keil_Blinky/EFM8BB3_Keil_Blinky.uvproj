# Keil uVision project EFM8BB3_Keil_Blinky.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8BB31F64G-QFN32 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xF9FF) CLOCK(49000000)
  output: EFM8BB3_Keil_Blinky
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SILABS_STARTUP.A51
